# Keil uVision project N32G452_DMA_USART.uvprojx, settings and files
target N32G452_DMA_USART (6160000::V6.16::ARMCLANG)
  device: N32G452VEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.6
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: N32G452_DMA_USART
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: N32G45X, USE_STDPERIPH_DRIVER
  c include: ..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\n32g45x_std_periph_driver\inc;..\Application\Inc;..\Middleware\Inc;..\BSP\Driver\Inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32g45x.c
  group FWLIB
    ../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_comp.c n32g45x_crc.c n32g45x_dac.c n32g45x_dbg.c n32g45x_dma.c n32g45x_dvp.c n32g45x_eth.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_iwdg.c n32g45x_opamp.c n32g45x_pwr.c n32g45x_qspi.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_spi.c n32g45x_tim.c n32g45x_tsc.c n32g45x_usart.c n32g45x_wwdg.c
  group BSP/Driver
    ../BSP/Driver/Src/: timer.c
  group Middleware
    ../Middleware/Src/: overflow_check.c
  group Application
    ../Application/Src/: main.cpp deliver_information.cpp
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
